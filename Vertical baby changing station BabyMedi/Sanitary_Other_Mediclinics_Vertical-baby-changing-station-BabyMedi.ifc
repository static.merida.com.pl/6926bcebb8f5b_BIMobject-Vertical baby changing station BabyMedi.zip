Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Other_Mediclinics_Vertical-baby-changing-station-BabyMedi.ifc
Time: 2020-02-06T13:48:59
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcBuildingElementProxy: Vertical baby changing station BabyMedi
ePset_BIMobjectScript - Type: Up; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Vertical baby changing station BabyMedi; SKU (BO_prodsku): CP0016V; ManufacturName (BO_Manufac): Mediclinics; BrandUrl (BO_brandurl): http://www.mediclinics.com/inicio; ProductFamily (BO_prodfam): Baby changing stations; ProductGroup (BO_prodgroup): BabyMedi®; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 550; Height (BO_height): 890; Depth (BO_depth): 100; Weight (BO_weight): 12.3; QR (BO_boqrurl): http://bimobject.com/mediclinics/product/CP0016V; ProductDataUrl (BO_prodaturl): bimobject.com/mediclinics/product/CP0016V; ProductUrl (BO_producturl): https://www.mediclinics.com/en/baby-changing-stations/1432-baby-changing-stations-CP0016V.html; InstallationInstructions (BO_montins): https://www.mediclinics.com/en/baby-changing-stations/1432-baby-changing-stations-CP0016V.html; ProductCertification (BO_prodcert): https://www.mediclinics.com/en/baby-changing-stations/1432-baby-changing-stations-CP0016V.html; TechnicalDescription (BO_techcert): https://www.mediclinics.com/en/baby-changing-stations/1432-baby-changing-stations-CP0016V.html; MaterialMain (BO_mainmat): Polypropylene; MaterialSecondary (BO_secmat): Steel; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Other; BimObjectCategoryCode (BO_bocat_code): sanitary-sanitary-other; IfcClassification (BO_ifcclas): Building Element Proxy; UnspscCode (BO_unspsc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L824; Uniclass14Description (BO_uniclass_1_4_desc): Bathroom, toilet furniture and fittings; Uniclass20Code (BO_uniclass_2_0_code): PR-35-75-06; Uniclass20Description (BO_uniclass_2_0_desc): Baby Changing Units; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_76_06; Uniclass2015Description (BO_uniclass2015_desc): Baby changing units; NBSReference (BO_nbs_ref): 35-75-06; NBSReferenceDescription (BO_nbs_desc): Baby Changing Units; OmniClassCode (BO_omniclass_code): 23-21 27 31 11; OmniClassDescription (BO_omniclass_name): Diaper Changing Tables; MasterFormat2014Code (BO_masterformat2014_code): 10 28 13.19; MasterFormat2014Description (BO_masterformat2014_name): Healthcare Toilet Accessories; UniFormat2Code (BO_uniformat2_code): E; UniFormat2Description (BO_uniformat2_name): EQUIPMENT & FURNISHINGS; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
